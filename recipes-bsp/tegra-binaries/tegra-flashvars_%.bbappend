# Fix UNPACKDIR variable expansion issue in scarthgap
S = "${UNPACKDIR}"
