# The base 1.16.2 recipe works correctly with scarthgap
# No modifications needed for this version
