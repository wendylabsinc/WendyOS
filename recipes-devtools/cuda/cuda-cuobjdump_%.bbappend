# Fix UNPACKDIR variable expansion issue in scarthgap
# Preserve ${BP} subdirectory where debian packages extract
S = "${WORKDIR}/${BP}"
