# Fix UNPACKDIR variable expansion issue in scarthgap
# Debian package extracts to subdirectory, preserve the path structure
S = "${WORKDIR}/l4t-graphics-demos/usr/src/nvidia/graphics_demos"
