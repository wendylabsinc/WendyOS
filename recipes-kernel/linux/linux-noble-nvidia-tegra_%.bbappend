
FILESEXTRAPATHS:prepend := "${THISDIR}/linux-jammy-nvidia-tegra:"

SRC_URI += " \
    file://usb-gadget.cfg \
    "

# file://enable_efi_stub.cfg
