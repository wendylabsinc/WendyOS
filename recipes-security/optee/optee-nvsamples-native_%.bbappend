# Whinlatter (Yocto 5.3) compatibility
# Set S to use UNPACKDIR to comply with whinlatter QA checks
S = "${UNPACKDIR}/samples"
